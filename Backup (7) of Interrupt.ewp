# IAR project Backup (7) of Interrupt.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91sam7s256 Atmel AT91SAM7S256
  ICCARM.CCDefines: ESS
  ICCARM.CCIncludePath2: srciar\; ..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: ..\..\include\
  XLINK.XclFile: resource\at91sam7s256_64KRAM.xcl
configuration Flash_Debug (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: resource\at91sam7s256_NoRemap.xcl
configuration Flash_Flash (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  XLINK.XclFile: resource\at91SAM7S256_NoRemap.xcl
  group Basic
    ./: cossintable.c main.c
  group Cstartup
    SrcIAR/: Cstartup.s79 Cstartup_SAM7.c
  group xRessource
    resource/: at91sam7s256_64KRAM.xcl at91sam7s256_NoRemap.xcl SAM7.mac SAM7_RAM.mac
